# Keil uVision project 4x4_matrix.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: 4x4_matrix +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: header.h main.c 4x4_mtx.c
    C:/Keil_v5/C51/Examples/: lcd_driver.c at24c512_driver.c i2c_driver.c ext_interrupt.c
